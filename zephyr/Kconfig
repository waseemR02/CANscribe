## zephyr/Kconfig
```kconfig
config CANSCRIBE
	bool "Enable CANscribe"
	help
	  This option enables CANscribe as a Zephyr module.
```
